options:
  parameters:
    generate_options: qt_gui
    id: rfid
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: num_ant
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '12'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    plotconst: 'False'
    plotfreq: 'False'
    plotwaterfall: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    plotconst: 'False'
    plotfreq: 'False'
    plotwaterfall: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rfidmimo_rx_dec_0
  id: rfidmimo_rx_dec
  parameters:
    num_ant: num_ant
    samp_rate: samp_rate
  states: {}
- name: rfidmimo_rx_det_0
  id: rfidmimo_rx_det
  parameters:
    num_ant: num_ant
    samp_rate: samp_rate
  states: {}
- name: rfidmimo_tx_send_0
  id: rfidmimo_tx_send
  parameters:
    num_ant: num_ant
    samp_rate: samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: 200e6
    dev_addr: '"addr=192.168.40.2"'
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: 200e6
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=192.168.40.2"'
    dev_args: '""'
    gain0: rx_gain
    gain1: rx_gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', qtgui_sink_x_1, '0']
- [blocks_complex_to_magphase_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0_0, '0', qtgui_sink_x_1_0, '0']
- [blocks_complex_to_magphase_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '1']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [rfidmimo_rx_dec_0, '0', rfidmimo_tx_send_0, '0']
- [rfidmimo_rx_dec_0, '1', rfidmimo_tx_send_0, '1']
- [rfidmimo_rx_det_0, '0', rfidmimo_rx_dec_0, '0']
- [rfidmimo_rx_det_0, '1', rfidmimo_rx_dec_0, '1']
- [rfidmimo_tx_send_0, '0', blocks_multiply_const_vxx_1, '0']
- [rfidmimo_tx_send_0, '1', blocks_multiply_const_vxx_0, '0']
- [rfidmimo_tx_send_0, '1', blocks_null_sink_1, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_magphase_0_0, '0']
- [uhd_usrp_source_0, '0', rfidmimo_rx_det_0, '0']
- [uhd_usrp_source_0, '1', blocks_complex_to_magphase_0, '0']
- [uhd_usrp_source_0, '1', rfidmimo_rx_det_0, '1']

metadata:
  file_format: 1
